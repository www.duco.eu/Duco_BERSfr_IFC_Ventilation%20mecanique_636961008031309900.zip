Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T17:07:39
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 17:07:39 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{55161999-6DB5-4E30-86AE-FE82A1D4710F}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 17:07:37 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 17:07:37 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 17:07:37 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDistributionControlElement: iq-unit_duco, BERSfr_67_EE_FB_iq-unit_duco:iq-unit_duco:200132
In: Level 1
Type - Classification: 67.10.10 (Uniformat); Material: BERSfr_x_rgb 000 149 150 T00 vert_gen, BERSfr_n_plastique_noir, BERSfr_o_vitrage_claire, BERSfr_n_plastique_gris
Type - Constraints(Type) - Default Elevation: 1200 mm
Type - Dimensions(Type) - BERSfr_C_épaisseur: 58.5 mm; BERSfr_C_hauteur: 106 mm; BERSfr_C_largeur: 164 mm
Type - Electrical(Type) - BERSfr_E_c02_facteur_de_puissance: 1; BERSfr_E_c02_indice_de_charge: HVAC; BERSfr_E_c02_nombre_des_pôles: 1; BERSfr_E_c02_puissance_active: 1.7 W; BERSfr_E_c02_sous_indice_de_charge_moteur: no; BERSfr_E_c02_tension: 220 V
Type - Identity Data(Type) - Assembly Code: 67.10.10; BERSfr_C_code_ETIM: Élément de commande intelligent; BERSfr_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC000205&classVersion=5; BERSfr_C_code_gtin: 5 4 2503715 030 9; BERSfr_C_code_produit: 0000-4193; BERSfr_C_content_créateur: ThorbiQ nv; BERSfr_C_content_date_modifié: 23/03/2018; BERSfr_C_content_date_problème: 26/02/2016; BERSfr_C_content_fournisseur: Duco; BERSfr_C_content_version: V4; BERSfr_C_description: IQ-Unit_duco; BERSfr_C_modèle: IQ-Unit; BERSfr_C_revit_version: 2014; BERSfr_C_type_commentaires: IQ-unit; Description: IQ-Unit_duco; Manufacturer: Duco; Model: IQ-Unit; Type Comments: IQ-unit; Type Name: iq-unit_duco; URL: http://www.duco.eu; WT_I BaseKeynote: 67.10.10
Type - Materials and Finishes(Type) - WT_V Boutons_matériel: BERSfr_n_plastique_gris; WT_V Display_matériel: BERSfr_o_vitrage_claire
Type - Model Properties(Type) - WT_I Communication: RF et Câblé; WT_I Confirmation: rail DIN; WT_I Connexions: 24VDC alimentation; Duco Wired; ModBus; contact de commutation (2x); PWM IN; PWM OUT; WT_I Couleur boîtier: Gris/blanc avec couleur logo Duco; WT_I Protocole: Z-wave; WT_I Type: IQ-unit
Type - Other(Type) - Category: Electrical Equipment; BERSfr_E_c01_description: c1_connecteur communication; BERSfr_E_c02_description: c2_connecteur électrique; Family Name: BERSfr_67_EE_FB_iq-unit_duco
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Area: 0.033179 m2; Volume: 0.00101696 m3
Electrical - Circuiting - Electrical Data: c2_connecteur électrique 220 V/1-2 VA
Identity Data - Mark: 1
Other - Category: Electrical Equipment; Family: BERSfr_67_EE_FB_iq-unit_duco: iq-unit_duco; Family and Type: BERSfr_67_EE_FB_iq-unit_duco: iq-unit_duco; Schedule Level: Level: Level 1; Type: BERSfr_67_EE_FB_iq-unit_duco: iq-unit_duco; Type Id: BERSfr_67_EE_FB_iq-unit_duco: iq-unit_duco
Phasing - Phase Created: New Construction
Text - BERSfr_C_content_instructions: http://www.witas.be/nl/duco
