Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T17:02:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 17:02:56 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{CB645F16-B8BA-4759-8338-B0CD55183499}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 17:02:52 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 17:02:52 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 17:02:52 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcFlowTerminal: doorvent_duco_doorvent, BERSfr_57_AIR_FB_passage d'air - doorvent_duco:doorvent_duco_doorvent:205091
In: Level 1
Type - PredefinedType: GRILLE; Classification: 57.10.90.1 (Uniformat); Material: BERSfr_h4_aluminium, BERSfr_n_plastique_noir
Type - Constraints(Type) - Default Elevation: 200 mm; ZZZ_endcaps_longeur_Length: 9.5 mm; ZZZ_excision_hauteur_Length: 48 mm; ZZZ_fond en saillie_hauteur_Length: 5 mm; ZZZ_grille l'exterieur_profondeur_Length: 2 mm; ZZZ_grille l'interieur_profondeur_Length: 2 mm; ZZZ_pose sur portes_YesNo: yes; ZZZ_top en saillie_hauteur_Length: 5 mm
Type - Dimensions(Type) - BERSfr_C_hauteur: 58 mm; BERSfr_C_longueur: 436 mm; WT_V Hauteur aérateur: 45 mm
Type - Identity Data(Type) - Assembly Code: 57.10.90.1; BERSfr_C_code_article: DoorVent; BERSfr_C_code_ETIM: Passage d'air; BERSfr_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC010230&classVersion=5; BERSfr_C_content_créateur: ThorbiQ nv; BERSfr_C_content_date_modifié: 23/03/2018; BERSfr_C_content_date_problème: 26/02/2016; BERSfr_C_content_fournisseur: Duco; BERSfr_C_content_version: V4; BERSfr_C_description: duco_Passage d'air_doorvent; BERSfr_C_modèle: DoorVent; BERSfr_C_revit_version: 2014; Manufacturer: Duco; Model: DoorVent; OmniClass Number: 3A(57.16.11); Type Name: doorvent_duco_doorvent; URL: http://www.duco.eu/producten/specificaties.cfm?prod=126&pid=3-126&cat=126; WT_I BaseKeynote: 57.10.90.1
Type - Materials and Finishes(Type) - BERSfr_C_matériel: BERSfr_h4_aluminium; WT_V Aérateur_matériel: BERSfr_a_perforé; WT_V Embouts_matériel: BERSfr_n_plastique_noir; WT_V profile extérieur_matériel: BERSfr_h4_aluminium; WT_V Profile intérieur_matériel: BERSfr_h4_aluminium
Type - Mechanical - Flow(Type) - WT_I Capacité de ventilation 10Pa: 0.52972 m3/s; WT_I Capacité de ventilation 2Pa: 0.245241 m3/s
Type - Model Properties(Type) - WT_I Couleur: F1 - RAL; WT_I Débit d'air: 0.007 m2; WT_I Différence de niveau sonore Dne, W_en position ouverte: 32 dB; WT_I Porte_MAX profondeur: 47 mm; WT_I Porte_MIN profondeur: 37 mm
Type - Other(Type) - Category: Air Terminals; Family Name: BERSfr_57_AIR_FB_passage d'air - doorvent_duco
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: doorvent_duco_doorvent
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1; ZZZ_excision_longeur_Length: 417 mm; ZZZ_grille l'interieur_longeur_Length: 413 mm; ZZZ_longeur flèche_Length: 241 mm; ZZZ_portes_profondeur_Length: 37 mm
Construction - WT_V Porte_profondeur: 37 mm
Dimensions - Area: 0.159529 m2; BERSfr_C_profondeur: 41 mm; Volume: 0.000968693 m3
Identity Data - Mark: 1
Mechanical - Flow - BE_M_pression_différentielle_10Pa: no; BE_M_pression_différentielle_2Pa: yes; BERSfr_M_débit: 0.101284 m3/s
Other - Category: Air Terminals; Family: BERSfr_57_AIR_FB_passage d'air - doorvent_duco: doorvent_duco_doorvent; Family and Type: BERSfr_57_AIR_FB_passage d'air - doorvent_duco: doorvent_duco_doorvent; Schedule Level: Level: Level 1; Type: BERSfr_57_AIR_FB_passage d'air - doorvent_duco: doorvent_duco_doorvent; Type Id: BERSfr_57_AIR_FB_passage d'air - doorvent_duco: doorvent_duco_doorvent
Phasing - Phase Created: New Construction
Text - BERSfr_C_content_instructions: http://www.witas.be/nl/duco
