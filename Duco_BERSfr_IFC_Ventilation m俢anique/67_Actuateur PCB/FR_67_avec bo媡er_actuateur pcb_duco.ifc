Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T17:06:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 17:06:56 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{B45FFE36-76E7-4D17-82E9-0CD02D557B9A}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 17:06:54 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 17:06:54 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 17:06:54 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcBuildingElementProxy: connector communication_gen (3)
In: Level 1
Type - Constraints(Type) - Default Elevation: 1219.2 mm
Type - Identity Data(Type) - Type Name: connector communication_gen
Type - Other(Type) - Category: Communication Devices; Family Name: BERSfr_XX_GM_FB_connector communication_gen
Pset_BuildingElementProxyCommon - Reference: connector communication_gen
Dimensions - Area: 0.0000942373 m2; Volume: 7.85051e-08 m3
Other - Category: Communication Devices; Family: BERSfr_XX_GM_FB_connector communication_gen: connector communication_gen; Family and Type: BERSfr_XX_GM_FB_connector communication_gen: connector communication_gen; Type: BERSfr_XX_GM_FB_connector communication_gen: connector communication_gen; Type Id: BERSfr_XX_GM_FB_connector communication_gen: connector communication_gen; WT_c1 utilitaire: no
Phasing - Phase Created: New Construction
Name (BERSfr_XX_GM_FB_connector communication_gen:connector communication_gen:...) | Mark | WT_c1 Description
200940 | 2 | c2_Commande à 2-ou 3 points
200941 | 3 | c3_PWM out
200942 | 4 | c4_Duco Câblé

# IfcDistributionControlElement: actuateur pcb_duco_avec boïter, BERSfr_67_COM_FB_actuateur pcb_duco:actuateur pcb_duco_avec boïter:200938
In: Level 1
Type - Classification: 67.10.10 (Uniformat)
Type - Constraints(Type) - Default Elevation: 1200 mm
Type - Dimensions(Type) - BERSfr_C_hauteur: 80 mm; BERSfr_C_largeur: 146 mm; BERSfr_C_profondeur: 58 mm
Type - Electrical(Type) - BERSfr_E_c01_facteur_de_puissance: 1; BERSfr_E_c01_indice_de_charge: HVAC; BERSfr_E_c01_nombre_des_pôles: 1; BERSfr_E_c01_puissance_active: 0 W; BERSfr_E_c01_sous_indice_de_charge_moteur: yes; BERSfr_E_c01_tension: 220 V
Type - Graphics(Type) - WT_V Visible: yes
Type - Identity Data(Type) - Assembly Code: 67.10.10; BERSfr_C_code_ETIM: Entraînement électrique avec vanne de commande circulaire chaîne; BERSfr_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC003086&classVersion=1; BERSfr_C_code_gtin: 5 4 2503715 007 1; BERSfr_C_code_produit: 0000-4195; BERSfr_C_content_créateur: ThorbiQ nv; BERSfr_C_content_date_modifié: 23/03/2018; BERSfr_C_content_date_problème: 26/02/2016; BERSfr_C_content_fournisseur: Duco; BERSfr_C_content_version: V4; BERSfr_C_description: actuateur pcb_duco_avec logement; BERSfr_C_modèle: actuateur pcb; BERSfr_C_revit_version: 2014; BERSfr_C_type: avec logement; BERSfr_C_type_commentaires: actuatorprint; Description: actuateur pcb_duco_avec logement; Manufacturer: Duco; Model: actuateur pcb; Type Comments: actuatorprint; Type Name: actuateur pcb_duco_avec boïter; URL: http://www.duco.eu; WT_I BaseKeynote: 67.10.10
Type - Model Properties(Type) - WT_I Communication: Câblé; WT_I Connexions: 2- of 3-controle du point (3 conducteurs); PWM out (2 conducteurs); Duco Wired (5 conducteurs); WT_I Couleur boîtier: Blanc; WT_I Type: Actuateur pcb
Type - Other(Type) - Category: Communication Devices; BERSfr_E_c01_description: c1_connecteur électrique; BERSfr_E_c02_description: c2_Commande à 2-ou 3 points; BERSfr_E_c03_description: c3_PWM out; BERSfr_E_c04_description: c4_Duco Câblé; Family Name: BERSfr_67_COM_FB_actuateur pcb_duco
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Construction - WT_V Commande à 2- ou 3 points: yes; WT_V Duco Câblé: yes; WT_V PWM out: yes
Dimensions - Area: 0.024788 m2; Volume: 0.00067744 m3
Electrical - Circuiting - Electrical Data: c1_connecteur électrique 220 V/1-0 VA
Graphics - WT_V Déplacement annotation x: 0 mm; WT_V Déplacement annotation y: 0 mm; WT_V Position annotation x: 0; WT_V Position annotation y: 0
Identity Data - Mark: 1
Other - Category: Communication Devices; Family: BERSfr_67_COM_FB_actuateur pcb_duco: actuateur pcb_duco_avec boïter; Family and Type: BERSfr_67_COM_FB_actuateur pcb_duco: actuateur pcb_duco_avec boïter; Schedule Level: Level: Level 1; Type: BERSfr_67_COM_FB_actuateur pcb_duco: actuateur pcb_duco_avec boïter; Type Id: BERSfr_67_COM_FB_actuateur pcb_duco: actuateur pcb_duco_avec boïter
Phasing - Phase Created: New Construction
Text - BERSfr_C_content_instructions: http://www.witas.be/nl/duco
