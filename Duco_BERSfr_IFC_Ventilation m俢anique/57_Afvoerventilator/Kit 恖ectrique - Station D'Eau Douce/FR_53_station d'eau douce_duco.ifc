Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T17:01:40
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 17:01:40 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{02D17088-473C-4570-AC9D-9721BC132CEC}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 17:01:38 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 17:01:38 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 17:01:38 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: station d'eau douce_duco_bxhxd 420x355x221, BERSfr_53_ME_FB_ducobox eco - kit électrique - station d'eau douce_duco:station d'eau douce_duco_bxhxd 420x355x221:207938
In: Level 1
Type - Classification: 53.10.10 (Uniformat); Material: BERSfr_x_rgb 20 20 20 T00 noir_gen, BERSfr_x_rgb 255 255 255 T00 blanc_gen
Type - Constraints(Type) - Default Elevation: 1219.2 mm
Type - Dimensions(Type) - BERSfr_C_hauteur: 355 mm; BERSfr_C_largeur: 420 mm; BERSfr_C_profondeur: 221 mm
Type - Electrical Engineering(Type) - BERSfr_E_c01_courant: 0 A; BERSfr_E_c01_facteur_de_puissance: 0; BERSfr_E_c01_indice_de_charge: HVAC; BERSfr_E_c01_nombre_des_pôles: 1; BERSfr_E_c01_puissance_apparente: 0 W; BERSfr_E_c01_sous_indice_de_charge_moteur: yes; BERSfr_E_c01_tension: 0 V
Type - Identity Data(Type) - Assembly Code: 53.10.10; BERSfr_C_code_article: 0000-4424_DucoBox Eco kit électrique AE1_station d'eau douce; BERSfr_C_content_créateur: ThorbiQ nv; BERSfr_C_content_date_modifié: 20/12/2018; BERSfr_C_content_fournisseur: Duco; BERSfr_C_content_version: 1.0.0; BERSfr_C_description: verswaterstation_duco; BERSfr_C_modèle: -; BERSfr_C_revit_version: 2016; BERSfr_C_type: -; BERSfr_C_type_commentaires: -; BERSnl_C_content_datum_uitgifte: 20/12/2018; Description: verswaterstation_duco; Model: -; Type Comments: -; Type Name: station d'eau douce_duco_bxhxd 420x355x221; WT_I BaseKeynote: 53.10.10
Type - Materials and Finishes(Type) - BERSfr_C_matériel: BERSfr_x_rgb 20 20 20 T00 noir_gen
Type - Other(Type) - Category: Mechanical Equipment; BERSfr_E_c01_description: c01_el; BERSfr_E_c02_description: c02_contrôle; BERSfr_P_c01_description: c01_EF; BERSfr_P_c01_diamètre: 25 mm; BERSfr_P_c02_description: c02_EC; BERSfr_P_c02_diamètre: 25 mm; BERSfr_P_c03_description: c03_EF; BERSfr_P_c03_diamètre: 25 mm; BERSfr_P_c04_description: c04_EC; BERSfr_P_c04_diamètre: 25 mm; Family Name: BERSfr_53_ME_FB_ducobox eco - kit électrique - station d'eau douce_duco; WT_V P_c01_plan: 1; WT_V P_c01_rotation hors du plan: 0 deg; WT_V P_c01_X: 150 mm; WT_V P_c01_Y: 39.5 mm; WT_V P_c01_Z: 0 mm; WT_V P_c02_plan: 1; WT_V P_c02_rotation hors du plan: 0 deg; WT_V P_c02_X: 70 mm; WT_V P_c02_Y: 39.5 mm; WT_V P_c02_Z: 0 mm; WT_V P_c03_plan: 2; WT_V P_c03_rotation hors du plan: 0 deg; WT_V P_c03_X: -150 mm; WT_V P_c03_Y: 39.5 mm; WT_V P_c03_Z: 0 mm; WT_V P_c04_plan: 2; WT_V P_c04_rotation hors du plan: 0 deg; WT_V P_c04_X: -70 mm; WT_V P_c04_Y: 39.5 mm; WT_V P_c04_Z: 0 mm
Pset_BuildingElementProxyCommon - Reference: station d'eau douce_duco_bxhxd 420x355x221
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Area: 1.91439 m2; Volume: 0.196563 m3
Identity Data - Mark: 1
Mechanical - System Classification: Domestic Cold Water,Domestic Hot Water,Domestic Cold Water,Domestic Hot Water,Power,Controls
Other - BERSfr_P_c01_débit_volumique: 0 m3/s; BERSfr_P_c02_débit_volumique: 0 m3/s; BERSfr_P_c03_débit_volumique: 0 m3/s; BERSfr_P_c04_débit_volumique: 0 m3/s; Category: Mechanical Equipment; Family: BERSfr_53_ME_FB_ducobox eco - kit électrique - station d'eau douce_duco: station d'eau douce_duco_bxhxd 420x355x221; Family and Type: BERSfr_53_ME_FB_ducobox eco - kit électrique - station d'eau douce_duco: station d'eau douce_duco_bxhxd 420x355x221; Schedule Level: Level: Level 1; Type: BERSfr_53_ME_FB_ducobox eco - kit électrique - station d'eau douce_duco: station d'eau douce_duco_bxhxd 420x355x221; Type Id: BERSfr_53_ME_FB_ducobox eco - kit électrique - station d'eau douce_duco: station d'eau douce_duco_bxhxd 420x355x221
Phasing - Phase Created: New Construction
Text - BERSfr_C_content_instructions: https://witasbvba.freshdesk.com/support/solutions/folders/43000225894
