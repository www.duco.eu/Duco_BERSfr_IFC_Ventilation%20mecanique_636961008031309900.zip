Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T17:07:25
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 17:07:25 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{022D4D4D-368B-4661-A80A-D0DD6954128F}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 17:07:23 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 17:07:23 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 17:07:23 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point

# IfcBuildingElementProxy: connector electrical_gen, BERSfr_XX_GM_FB_connector electrical_gen:connector electrical_gen:202950
In: Level 1
Type - Constraints(Type) - Default Elevation: 1219.2 mm
Type - Identity Data(Type) - BERSfr_C_description: connector electrical_gen; Type Name: connector electrical_gen
Type - Other(Type) - Category: Communication Devices; Family Name: BERSfr_XX_GM_FB_connector electrical_gen
Pset_BuildingElementProxyCommon - Reference: connector electrical_gen
Dimensions - Area: 0.0000942373 m2; Volume: 7.85051e-08 m3
Electrical - BERSfr_E_c02_facteur_de_puissance: 1; BERSfr_E_c02_indice_de_charge: HVAC; BERSfr_E_c02_nombre_des_pôles: 1; BERSfr_E_c02_sous_indice_de_charge_moteur: no; BERSfr_E_c02_tension: 24 V; BERSfr_E_puissance: 1 W
Electrical - Circuiting - Electrical Data: c2_connecteur électrique 24 V/1-1 VA
Identity Data - Mark: 2
Other - Category: Communication Devices; Family: BERSfr_XX_GM_FB_connector electrical_gen: connector electrical_gen; Family and Type: BERSfr_XX_GM_FB_connector electrical_gen: connector electrical_gen; Type: BERSfr_XX_GM_FB_connector electrical_gen: connector electrical_gen; Type Id: BERSfr_XX_GM_FB_connector electrical_gen: connector electrical_gen; WT_c1 Description: c2_connecteur électrique; WT_c2 utilitaire: no
Phasing - Phase Created: New Construction

# IfcDistributionControlElement: wired_duco_commutateur de commande, BERSfr_67_COM_FB_panneau de commande_duco:wired_duco_commutateur de commande:202948
In: Level 1
Type - Classification: 67.10 (Uniformat); Material: BERSfr_n_plastique_blanc, BERSfr_n_plastique_noir
Type - Constraints(Type) - Default Elevation: 1200 mm; ZZZ_batterie_YesNo: no; ZZZ_électriquee connection_YesNo: yes
Type - Construction(Type) - WT_V Epaisseur cadre de recouvrement: 20 mm; WT_V Profondeur de montage: 40 mm
Type - Dimensions(Type) - BERSfr_C_épaisseur: 60 mm; BERSfr_C_hauteur: 83 mm; BERSfr_C_largeur: 83 mm
Type - Electrical(Type) - BERSfr_E_c02_facteur_de_puissance: 1; BERSfr_E_c02_indice_de_charge: HVAC; BERSfr_E_c02_nombre_des_pôles: 1; BERSfr_E_c02_puissance_active: 1 W; BERSfr_E_c02_sous_indice_de_charge_moteur: no; BERSfr_E_c02_tension: 24 V; WT_I Stand-By puissance: 0.5 W
Type - Identity Data(Type) - Assembly Code: 67.10; BERSfr_C_code_ETIM: Dispositif de contrôle /plaque de commutation centrale; BERSfr_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC000011&classVersion=6; BERSfr_C_code_gtin: 5 4 2503715 010 1; BERSfr_C_code_produit: 0000-4177; BERSfr_C_content_créateur: ThorbiQ nv; BERSfr_C_content_date_modifié: 23/03/2018; BERSfr_C_content_date_problème: 26/02/2016; BERSfr_C_content_fournisseur: Duco; BERSfr_C_content_version: V4; BERSfr_C_description: wired_duco_interrupteur de commande; BERSfr_C_modèle: commutateur de commande; BERSfr_C_revit_version: 2014; BERSfr_C_type: wired; BERSfr_C_type_commentaires: commutateur de commande; Description: wired_duco_interrupteur de commande; Manufacturer: Duco; Model: commutateur de commande; Type Comments: commutateur de commande; Type Name: wired_duco_commutateur de commande; URL: http://www.duco.eu/nl-nl-producten/nl-nl-ventilatiesystemen/nl-nl-sturingscomponenten/nl-nl-bedieningsschakelaar; WT_I BaseKeynote: 67.10.10
Type - Materials and Finishes(Type) - BERSfr_C_matériel: BERSfr_n_plastique_blanc
Type - Model Properties(Type) - WT_I Couleur boîtier: commande noire; WT_I Indication de couleur LED_BLEU: La visualisation du commutateur de commande lorsque des modifications sont apportées à travers le DucoBox; WT_I Indication de couleur LED_JAUNE_clignotent: Phase de transition (si DucoBox pas dans la portée); WT_I Indication de couleur LED_ROUGE_clignotent lentement: Pas dans le réseau; WT_I Indication de couleur LED_ROUGE_clignotent rapidement: Connectez; WT_I Indication de couleur LED_VERT_clignotent lentement: Dans le réseau; WT_I Indication de couleur LED_VERT_clignotent rapidement: En réseau et en attendant les componentes sous-jacents ( ex. Grille éléctronique ); WT_I Profondeur_boîtier fixation: 40 mm; WT_I Protocole: Z-wave; WT_I Type: Câblé_24VDC
Type - Other(Type) - Category: Communication Devices; BERSfr_E_c01_description: c1_connecteur communication; BERSfr_E_c02_description: c2_connecteur électrique; Family Name: BERSfr_67_COM_FB_panneau de commande_duco
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Area: 0.0170067 m2; Volume: 0.000419885 m3
Graphics - WT_V Déplacement annotation x: 0 mm; WT_V Déplacement annotation y: 0 mm; WT_V Position annotation x: 0; WT_V Position annotation y: 0
Identity Data - Mark: 1
Other - Category: Communication Devices; Family: BERSfr_67_COM_FB_panneau de commande_duco: wired_duco_commutateur de commande; Family and Type: BERSfr_67_COM_FB_panneau de commande_duco: wired_duco_commutateur de commande; Schedule Level: Level: Level 1; Type: BERSfr_67_COM_FB_panneau de commande_duco: wired_duco_commutateur de commande; Type Id: BERSfr_67_COM_FB_panneau de commande_duco: wired_duco_commutateur de commande
Phasing - Phase Created: New Construction
Text - BERSfr_C_content_instructions: http://www.witas.be/nl/duco
