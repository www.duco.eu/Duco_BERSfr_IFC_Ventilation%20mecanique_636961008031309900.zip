Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T17:05:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 17:05:33 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{913DA978-15EC-4ED6-97DF-BDDAD9467803}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 17:05:32 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 17:05:32 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 17:05:32 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point

# IfcDistributionControlElement: support de montage suspendu_duco, BERSfr_59_ME_FB_support de montage - SH_duco:support de montage suspendu_duco:219654
In: Level 1
Type - Classification: 67.10.10 (Uniformat); Material: BERSfr_x_rgb 248 248 248 T00 blanc_gen
Type - Constraints(Type) - Default Elevation: 0 mm
Type - Construction(Type) - WT_V Suspendu: yes
Type - Dimensions(Type) - BERSfr_C_diamètre: 0 mm; BERSfr_C_hauteur: 1032 mm; BERSfr_C_largeur: 740 mm; BERSfr_C_profondeur: 568 mm
Type - Identity Data(Type) - Assembly Code: 67.10.10; BERSfr_C_code_article: 0000-4422; BERSfr_C_code_ETIM: Ventilateur domestique; BERSfr_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC010004&classVersion=5; BERSfr_C_code_gtin: -; BERSfr_C_content_créateur: ThorbiQ nv; BERSfr_C_content_date_modifié: 20/12/2018; BERSfr_C_content_fournisseur: Duco; BERSfr_C_content_version: 1.0.0; BERSfr_C_description: support de montage suspendu_duco; BERSfr_C_IFC_version: 2x3; BERSfr_C_modèle: support de montage; BERSfr_C_revit_version: 2016; BERSfr_C_type: suspendu; BERSfr_C_type_commentaires: duco_support de montage suspendu; BERSnl_C_content_datum_uitgifte: 20/12/2018; Description: support de montage suspendu_duco; Manufacturer: Duco; Model: support de montage; OmniClass Number: 23.75.70.17.37; OmniClass Title: Unit Ventilators; Type Comments: duco_support de montage suspendu; Type Name: support de montage suspendu_duco; URL: http://www.duco.eu/nl-nl-producten/nl-nl-ventilatiesystemen/nl-nl-sturingscomponenten/nl-nl-boxsensor; WT_I BaseKeynote: 67.10.10
Type - Materials and Finishes(Type) - BERSfr_C_matériel: BERSfr_x_rgb 248 248 248 T00 blanc_gen
Type - Other(Type) - Category: Mechanical Equipment; Family Name: BERSfr_59_ME_FB_support de montage - SH_duco
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Constraints - Moves With Nearby Elements: no; Offset: 1 mm
Dimensions - Area: 0.546266 m2; Volume: 0.0125291 m3
Identity Data - Mark: 76
Other - Category: Mechanical Equipment; Family: BERSfr_59_ME_FB_support de montage - SH_duco: support de montage suspendu_duco; Family and Type: BERSfr_59_ME_FB_support de montage - SH_duco: support de montage suspendu_duco; Type: BERSfr_59_ME_FB_support de montage - SH_duco: support de montage suspendu_duco; Type Id: BERSfr_59_ME_FB_support de montage - SH_duco: support de montage suspendu_duco
Phasing - Phase Created: New Construction
Text - BERSfr_C_content_instructions: https://witasbvba.freshdesk.com/support/solutions/folders/43000225894

# IfcEnergyConversionDevice: 400-1zh - droite - support de montage suspendu_duco_ducobox energy_bxhxd 740x957x585 mm, BERSfr_57_ME_FB_appareil de récupération de chaleur ducobox energy_duco:400-1zh - droite - support de montage suspendu_duco_ducobox energy_bxhxd 740x957x585 mm:219653
In: Level 1
Type - PredefinedType: AIRHANDLER; Classification: 57.21 (Uniformat); Material: BERSfr_x_rgb 20 20 20 T00 noir_gen, BERSfr_x_rgb 255 255 255 T00 blanc_gen, BERSfr_x_rgb 000 149 150 T00 vert_gen
Type - Constraints(Type) - Default Elevation: 1000 mm
Type - Dimensions(Type) - BERSfr_C_hauteur: 957 mm; BERSfr_C_largeur: 740 mm; BERSfr_C_profondeur: 585 mm
Type - Electrical(Type) - BERSfr_E_c01_courant: 1 A; BERSfr_E_c01_facteur_de_puissance: 1; BERSfr_E_c01_indice_de_charge: HVAC; BERSfr_E_c01_nombre_des_pôles: 1; BERSfr_E_c01_puissance_apparente: 230 W; BERSfr_E_c01_sous_indice_de_charge_moteur: no; BERSfr_E_c01_tension: 230 V
Type - Identity Data(Type) - Assembly Code: 57.21; BERSfr_C_code_article: 0000-4369; BERSfr_C_code_ETIM: WTW apparaat eengezinswoning; BERSfr_C_code_ETIM_url: https://prod.etim-international.com/Class/Details?classId=EC011285&classVersion=3; BERSfr_C_code_gtin: -; BERSfr_C_content_créateur: ThorbiQ nv; BERSfr_C_content_date_modifié: 20/12/2018; BERSfr_C_content_fournisseur: Duco; BERSfr_C_content_version: 1.0.0; BERSfr_C_description: ducobox energy - 400-1zh - droite_duco; BERSfr_C_modèle: DucoBox Energy; BERSfr_C_revit_version: 2016; BERSfr_C_type: 400-1ZH - droite; BERSfr_C_type_commentaires: -; BERSnl_C_content_datum_uitgifte: 20/12/2018; Description: ducobox energy - 400-1zh - droite_duco; Manufacturer: Duco; Model: DucoBox Energy; OmniClass Number: 3A(57.31.11); Type Comments: -; Type Name: 400-1zh - droite - support de montage suspendu_duco_ducobox energy_bxhxd 740x957x585 mm; WT_I BaseKeynote: 57.21
Type - Materials and Finishes(Type) - BERSfr_C_matériel: BERSfr_x_rgb 000 149 150 T00 vert_gen; BERSfr_C_matériel_01: BERSfr_x_rgb 000 149 150 T00 vert_gen; BERSfr_C_matériel_02: BERSfr_x_rgb 255 255 255 T00 blanc_gen; BERSfr_C_matériel_03: BERSfr_x_rgb 20 20 20 T00 noir_gen; WT_V Maintenance zones_materiaal: BERSfr_x_rgb 255 0 0 T80 rouge_gen
Type - Mechanical(Type) - WT_V Capacité: 4.51243 m3/s; WT_V Hauteur d'élévation: 150 Pa
Type - Model Properties(Type) - WT_I Capacité extraction à 150Pa: 400 m³/h; WT_I Chauffage: avec chauffage; WT_I Classe énergétique: A+; WT_I Côntrole de zone: 1 zone; WT_I Diamètre extérieur: 190 mm; WT_I Diamètre intérieur: 160 mm; WT_I Poids: 47 kg; WT_I Puissance maximale: 2 x 58 W
Type - Other(Type) - Category: Mechanical Equipment; BERSfr_E_c01_description: c01_Elektrische aansluiting; BERSfr_E_c02_description: c02_Communication aansluiting; BERSfr_M_c01_description: c01_décharge à l'extérieur_EHA; BERSfr_M_c01_diamètre: 160 mm; BERSfr_M_c02_description: c02_l'alimentation vers l'extérieur_ODA; BERSfr_M_c02_diamètre: 160 mm; BERSfr_M_c03_description: c03_décharger de l'intérieur_ETA; BERSfr_M_c03_diamètre: 160 mm; BERSfr_M_c04_description: c04_alimentation à l'intérieur_SUP 1; BERSfr_M_c04_diamètre: 160 mm; BERSfr_M_c05_description: c05_alimentation à l'intérieur_SUP 2; BERSfr_M_c05_diamètre: 160 mm; BERSfr_P_c03_description: c01_ drainage; BERSfr_P_c03_diamètre: 32 mm; BERSfr_P_c03_unité_de_raccordement: 0; Family Name: BERSfr_57_ME_FB_appareil de récupération de chaleur ducobox energy_duco; WT_V M_c01_plan: 4; WT_V M_c01_rotation hors du plan: 0 deg; WT_V M_c01_X: 248 mm; WT_V M_c01_Y: -141 mm; WT_V M_c01_Z: -50 mm; WT_V M_c02_plan: 4; WT_V M_c02_rotation hors du plan: 0 deg; WT_V M_c02_X: -57 mm; WT_V M_c02_Y: -141 mm; WT_V M_c02_Z: -50 mm; WT_V M_c03_plan: 4; WT_V M_c03_rotation hors du plan: -45 deg; WT_V M_c03_X: -289 mm; WT_V M_c03_Y: -141 mm; WT_V M_c03_Z: -131.6 mm; WT_V M_c04_plan: 4; WT_V M_c04_rotation hors du plan: -45 deg; WT_V M_c04_X: -289 mm; WT_V M_c04_Y: 135 mm; WT_V M_c04_Z: -131.6 mm; WT_V M_c05_plan: 4; WT_V M_c05_rotation hors du plan: 0 deg; WT_V M_c05_X: -57 mm; WT_V M_c05_Y: 135 mm; WT_V M_c05_Z: -50 mm; WT_V P_c03_plan: 3; WT_V P_c03_rotation hors du plan: 0 deg; WT_V P_c03_X: -258 mm; WT_V P_c03_Y: 138 mm; WT_V P_c03_Z: -10 mm
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: 400-1zh - droite - support de montage suspendu_duco_ducobox energy_bxhxd 740x957x585 mm
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Construction - WT_V Câble coaxial: no; WT_V Humidité capteur de box: no; WT_V Print de communication: no; WT_V Print de communication_visible: no; WT_V Siphon platte: no
Dimensions - Area: 28.8043 m2; Volume: 7.53427 m3
Graphics - WT_V Espace d'entretien visible: no
Identity Data - Mark: 75
Mechanical - System Classification: Exhaust Air,Supply Air,Return Air,Supply Air,Sanitary,Power,Communication,Supply Air
Mechanical - Flow - BERSfr_M_débit: 0 m3/s
Other - BERSfr_M_c01_débit: 0 m3/s; BERSfr_M_c02_débit: 0 m3/s; BERSfr_M_c03_débit: 0 m3/s; BERSfr_M_c04_débit: 0 m3/s; BERSfr_M_c05_débit: 0 m3/s; Category: Mechanical Equipment; Family: BERSfr_57_ME_FB_appareil de récupération de chaleur ducobox energy_duco: 400-1zh - droite - support de montage suspendu_duco_ducobox energy_bxhxd 740x957x585 mm; Family and Type: BERSfr_57_ME_FB_appareil de récupération de chaleur ducobox energy_duco: 400-1zh - droite - support de montage suspendu_duco_ducobox energy_bxhxd 740x957x585 mm; Schedule Level: Level: Level 1; Type: BERSfr_57_ME_FB_appareil de récupération de chaleur ducobox energy_duco: 400-1zh - droite - support de montage suspendu_duco_ducobox energy_bxhxd 740x957x585 mm; Type Id: BERSfr_57_ME_FB_appareil de récupération de chaleur ducobox energy_duco: 400-1zh - droite - support de montage suspendu_duco_ducobox energy_bxhxd 740x957x585 mm
Phasing - Phase Created: New Construction
Text - BERSfr_C_content_instructions: https://witasbvba.freshdesk.com/support/solutions/folders/43000225894
