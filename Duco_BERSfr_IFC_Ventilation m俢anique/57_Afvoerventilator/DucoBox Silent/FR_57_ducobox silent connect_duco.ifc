Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T17:06:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 17:06:05 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{3A379AE9-2C2B-4E7B-BD65-15876F0491BD}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 17:06:04 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 17:06:04 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 17:06:04 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcEnergyConversionDevice: ducobox silent connect_duco, BERSfr_57_ME_FB_ventilateur d'extraction ducobox silent_duco:ducobox silent connect_duco:205660
In: Level 1
Type - PredefinedType: AIRHANDLER; Classification: 57.21 (Uniformat); Material: BERSfr_x_rgb 000 149 150 T00 vert_gen, BERSfr_x_rgb 255 255 255 T00 blanc_gen
Type - Constraints(Type) - Default Elevation: 1219.2 mm
Type - Construction(Type) - WT_V Espace d'entretien_profondeur: 500 mm
Type - Dimensions(Type) - BERSfr_C_hauteur: 480 mm; BERSfr_C_largeur: 480 mm; BERSfr_C_profondeur: 195 mm
Type - Electrical(Type) - BERSfr_E_c01_courant: 1 A; BERSfr_E_c01_facteur_de_puissance: 1; BERSfr_E_c01_indice_de_charge: HVAC; BERSfr_E_c01_nombre_des_pôles: 1; BERSfr_E_c01_puissance_apparente: 230 W; BERSfr_E_c01_sous_indice_de_charge_moteur: no; BERSfr_E_c01_tension: 230 V
Type - Identity Data(Type) - Assembly Code: 57.21; BERSfr_C_code_article: 0000-4250; BERSfr_C_code_ETIM: Ventilateur de maison; BERSfr_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC010004&classVersion=5; BERSfr_C_content_créateur: ThorbiQ nv; BERSfr_C_content_date_issue: 26/02/2016; BERSfr_C_content_date_modifié: 23/03/2018; BERSfr_C_content_fournisseur: Duco; BERSfr_C_content_version: V5; BERSfr_C_description: ducobox silent connect_duco; BERSfr_C_modèle: DucoBox Silent; BERSfr_C_revit_version: 2016; BERSfr_C_type_commentaires: ventilateur d'extraction; Description: ducobox silent connect_duco; Manufacturer: Duco; Model: DucoBox Silent; OmniClass Number: 3A(57.31.11); Type Comments: ventilateur d'extraction; Type Name: ducobox silent connect_duco; URL: http://www.duco.eu/architects/nl-nl-producten/nl-nl-luchtafvoer/nl-nl-mechanische-afvoer/nl-nl-ducoboxsilent; WT_I BaseKeynote: 57.21
Type - Mechanical(Type) - WT_V Capacité: 3.92385 m3/s; WT_V Hauteur d'élévation: 150 Pa
Type - Model Properties(Type) - WT_I Extraction_réglage: Central; WT_I Puissance sonore_aspiration: 57.5; WT_I Puissance sonore_dispersion box: 46.5; WT_I Systèmes de clapet de régulation breveté: no
Type - Other(Type) - Category: Mechanical Equipment; BERSfr_E_c01_description: c01_connection électrque; BERSfr_E_c02_description: c02_connection de communication; BERSfr_M_c01_description: c01_échappement; BERSfr_M_c01_rayon: 62.5 mm; BERSfr_M_c02_description: c02_extration 1; BERSfr_M_c03_description: c03_extration 2; BERSfr_M_c04_description: c04_extration 3; BERSfr_M_c05_description: c05_extration 4; BERSfr_M_c06_description: c06_extration 5; BERSfr_M_c06_rayon: 62.5 mm; BERSfr_M_c07_description: c07_extration 6; BERSfr_M_c07_rayon: 62.5 mm; BERSfr_M_c08_description: c08_extration 7; BERSfr_M_c08_rayon: 62.5 mm; Family Name: BERSfr_57_ME_FB_ventilateur d'extraction ducobox silent_duco
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: ducobox silent connect_duco
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Construction - WT_V CO2 sonde: no; WT_V Commande_IQ enfichable: yes; WT_V Commande_Print PWM enfichable + IQ externe: no; WT_V Commande_Sans fil: no; WT_V EasySwitch: no; WT_V Embout visible_1: yes; WT_V Embout visible_2: yes; WT_V Embout visible_3: yes; WT_V Embout visible_4: yes; WT_V Embout visible_5: yes; WT_V Embout visible_6: yes; WT_V Embout visible_7: yes; WT_V Humidité capteur de box: no; WT_V print de communication: no; WT_V print de communication_visible: no
Dimensions - Area: 1.2228 m2; Volume: 0.044928 m3
Graphics - WT_V Espace d'entretien visible: no
Identity Data - Mark: 3
Mechanical - System Classification: Return Air,Exhaust Air,Return Air,Power,Communication,Return Air
Mechanical - Flow - BERSfr_M_débit: 0 m3/s
Other - BERSfr_M_c01_débit: 0 m3/s; BERSfr_M_c02_débit: 0 m3/s; BERSfr_M_c02_rayon: 62.5 mm; BERSfr_M_c03_débit: 0 m3/s; BERSfr_M_c03_rayon: 62.5 mm; BERSfr_M_c04_débit: 0 m3/s; BERSfr_M_c04_rayon: 62.5 mm; BERSfr_M_c05_débit: 0 m3/s; BERSfr_M_c05_rayon: 62.5 mm; BERSfr_M_c06_débit: 0 m3/s; BERSfr_M_c07_débit: 0 m3/s; BERSfr_M_c08_débit: 0 m3/s; Category: Mechanical Equipment; Family: BERSfr_57_ME_FB_ventilateur d'extraction ducobox silent_duco: ducobox silent connect_duco; Family and Type: BERSfr_57_ME_FB_ventilateur d'extraction ducobox silent_duco: ducobox silent connect_duco; Schedule Level: Level: Level 1; Type: BERSfr_57_ME_FB_ventilateur d'extraction ducobox silent_duco: ducobox silent connect_duco; Type Id: BERSfr_57_ME_FB_ventilateur d'extraction ducobox silent_duco: ducobox silent connect_duco
Phasing - Phase Created: New Construction
Text - BERSfr_C_content_instructions: http://www.witas.be/nl/duco
