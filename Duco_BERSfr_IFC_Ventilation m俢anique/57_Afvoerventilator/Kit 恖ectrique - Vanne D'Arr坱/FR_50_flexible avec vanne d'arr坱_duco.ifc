Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T17:00:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 17:00:53 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{3AABF62A-C3EB-469E-B9D0-84D53356FFAE}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 17:00:51 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 17:00:51 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 17:00:51 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: flexible avec vanne d'arrêt_duco, BERSfr_50_PIA_UH_ducobox eco - kit électrique - vanne d'arrêt_duco:flexible avec vanne d'arrêt_duco:208206
In: Level 1
Type - Classification: 50 (Uniformat); Material: BERSfr_x_rgb 255 255 255 T00 blanc_gen
Type - Dimensions(Type) - BERSfr_C_hauteur: 38 mm; BERSfr_C_largeur: 64 mm; BERSfr_C_profondeur: 38 mm
Type - Identity Data(Type) - Assembly Code: 50; BERSfr_C_code_article: 0000-4424_DucoBox Eco All Electric Kit AE1_Aansluitflexibel met afsluitkraan; BERSfr_C_content_créateur: ThorbiQ nv; BERSfr_C_content_date_modifié: 20/12/2018; BERSfr_C_content_fournisseur: Duco; BERSfr_C_content_version: 1.0.0; BERSfr_C_description: aansluitflexibel met afsluitkraan_duco; BERSfr_C_modèle: -; BERSfr_C_revit_version: 2016; BERSfr_C_type: -; BERSfr_C_type_commentaires: -; BERSnl_C_content_datum_uitgifte: 20/12/2018; Description: aansluitflexibel met afsluitkraan_duco; Model: -; Type Comments: -; Type Name: flexible avec vanne d'arrêt_duco; WT_I BaseKeynote: 50
Type - Materials and Finishes(Type) - BERSfr_C_matériel: BERSfr_x_rgb 255 255 255 T00 blanc_gen
Type - Other(Type) - Category: Pipe Accessories; BERSfr_P_c01_diamètre: 25 mm; BERSfr_P_c02_diamètre: 25 mm; Family Name: BERSfr_50_PIA_UH_ducobox eco - kit électrique - vanne d'arrêt_duco; WT_V P_c01_plan: 5; WT_V P_c01_X: 0 mm; WT_V P_c01_Y: 0 mm; WT_V P_c01_Z: -8 mm; WT_V P_c02_plan: 6; WT_V P_c02_X: 0 mm; WT_V P_c02_Y: 0 mm; WT_V P_c02_Z: -8 mm
Pset_DistributionFlowElementCommon - Reference: flexible avec vanne d'arrêt_duco
Constraints - Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0202363 m2; Maximum Size: 25 mm; Minimum Size: 25 mm; Size: 25 mmø-25 mmø; Volume: 0.00027819 m3
Identity Data - Mark: 1
Insulation - Insulation Thickness: 0 mm; Overall Size: 25 mmø-25 mmø
Mechanical - System Classification: Undefined
Other - Category: Pipe Accessories; Family: BERSfr_50_PIA_UH_ducobox eco - kit électrique - vanne d'arrêt_duco: flexible avec vanne d'arrêt_duco; Family and Type: BERSfr_50_PIA_UH_ducobox eco - kit électrique - vanne d'arrêt_duco: flexible avec vanne d'arrêt_duco; Type: BERSfr_50_PIA_UH_ducobox eco - kit électrique - vanne d'arrêt_duco: flexible avec vanne d'arrêt_duco; Type Id: BERSfr_50_PIA_UH_ducobox eco - kit électrique - vanne d'arrêt_duco: flexible avec vanne d'arrêt_duco
Phasing - Phase Created: New Construction
Text - BERSfr_C_content_instructions: https://witasbvba.freshdesk.com/support/solutions/folders/43000225894
