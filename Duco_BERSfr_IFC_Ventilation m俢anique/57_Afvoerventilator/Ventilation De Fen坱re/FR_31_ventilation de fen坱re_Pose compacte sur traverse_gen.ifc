Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T17:00:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 17:00:23 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{4F1D4755-CDFE-41E3-8DEE-3DC2B4405D49}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 17:00:23 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 17:00:23 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 17:00:23 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point

# IfcFlowTerminal: Pose compacte sur traverse_gen_ventilation de fenêtre, BERSfr_31_AIR_FB_ventilation de fenêtre_gen:Pose compacte sur traverse_gen_ventilation de fenêtre:199466
In: Level 1
Type - PredefinedType: GRILLE; Classification: 31.2 (Uniformat); Material: BERSfr_h4_aluminium
Type - Constraints(Type) - Default Elevation: 1500 mm; ZZZ_excision_hauteur_Length: 70 mm; ZZZ_fenêtre ou vitrage_profondeur_Length: 80 mm; ZZZ_longeur flèche_Length: 291 mm
Type - Construction(Type) - WT_V Embouts_longueur: 35 mm; WT_V Excision_hauteur: 70 mm; WT_V Fenêtre ou vitrage_profondeur: 80 mm; WT_V Grille extérieur_profondeur: 0 mm; WT_V Grille intérieur_profondeur: 11 mm; WT_V Pose sur châssis: no; WT_V Pose sur traverse: no; WT_V Pose sur traverse_compact: yes; WT_V Pose sur vitrage: no; WT_V Projection inférieure_hauteur: 19 mm; WT_V Projection supérieure_hauteur: 19 mm
Type - Dimensions(Type) - BERSfr_C_hauteur: 88 mm; BERSfr_C_profondeur: 91 mm; WT_V Hauteur aérateur: 0 mm
Type - Identity Data(Type) - Assembly Code: 31.2; BERSfr_C_code_ETIM: Passage d'air; BERSfr_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC010230&classVersion=5; BERSfr_C_content_créateur: ThorbiQ nv; BERSfr_C_content_date_modifié: 23/03/2018; BERSfr_C_content_date_problème: 26/02/2016; BERSfr_C_content_fournisseur: ThorbiQ nv; BERSfr_C_content_version: V4; BERSfr_C_description: gen_ventilation de fenêtre_Pose compacte sur traverse; BERSfr_C_modèle: -; BERSfr_C_revit_version: 2014; Manufacturer: gen; Model: -; OmniClass Number: 3A(57.16.11); Type Name: Pose compacte sur traverse_gen_ventilation de fenêtre; WT_I BaseKeynote: 31.2
Type - Materials and Finishes(Type) - BERSfr_C_matériel: BERSfr_h4_aluminium; WT_V Embouts_matériel: BERSfr_n_plastique_noir
Type - Mechanical - Flow(Type) - WT_I Capacité de ventilation 10Pa: 0 m3/s; WT_I Capacité de ventilation 2Pa: 0 m3/s
Type - Other(Type) - Category: Air Terminals; Family Name: BERSfr_31_AIR_FB_ventilation de fenêtre_gen
Pset_ManufacturerTypeInformation - Manufacturer: gen
Pset_DistributionFlowElementCommon - Reference: Pose compacte sur traverse_gen_ventilation de fenêtre
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1; ZZZ_excision_longeur_Length: 1200 mm; ZZZ_grille l'interieur_longeur_Length: 1130 mm
Dimensions - Area: 0.293518 m2; BERSfr_C_longueur: 1200 mm; Volume: 0.0066216 m3
Identity Data - Mark: 7
Mechanical - Flow - BERSfr_M_débit: 0 m3/s; ZZZ_pression différentielle 10Pa_YesNo: no; ZZZ_pression différentielle 2Pa_YesNo: yes
Other - Category: Air Terminals; Family: BERSfr_31_AIR_FB_ventilation de fenêtre_gen: Pose compacte sur traverse_gen_ventilation de fenêtre; Family and Type: BERSfr_31_AIR_FB_ventilation de fenêtre_gen: Pose compacte sur traverse_gen_ventilation de fenêtre; Schedule Level: Level: Level 1; Type: BERSfr_31_AIR_FB_ventilation de fenêtre_gen: Pose compacte sur traverse_gen_ventilation de fenêtre; Type Id: BERSfr_31_AIR_FB_ventilation de fenêtre_gen: Pose compacte sur traverse_gen_ventilation de fenêtre
Phasing - Phase Created: New Construction
Text - BERSfr_C_content_instructions: http://www.witas.be/nl/families
