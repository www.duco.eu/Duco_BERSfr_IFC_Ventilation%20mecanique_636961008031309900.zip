Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T17:03:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 17:03:13 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{C81E2232-6EDE-4F38-80D9-E53391FAB3E6}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 17:03:09 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 17:03:10 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 17:03:10 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowFitting: 2 x 125mm naar 1 x 160 mm_duco_culottes type d'y, BERSfr_57_DUF_UN_culottes type d'y_duco:2 x 125mm naar 1 x 160 mm_duco_culottes type d'y:199360
In: Level 1
Type - PredefinedType: TRANSITION; Classification: 57,1 (Uniformat); Material: BERSfr_x_rgb 20 20 20 T00 noir_gen
Type - Constraints(Type) - WT_V Longueur totale_01: 180 mm
Type - Construction(Type) - WT_V Distance_01: 0 mm; WT_V Distance_02: 40 mm; WT_V Distance_03: 170 mm; WT_V Longueur_01: 50 mm; WT_V Longueur_02: 50 mm; WT_V Longueur_03: 25 mm; WT_V Longueur inkeping: 180 mm; WT_V Longueur totale: 230 mm
Type - Dimensions(Type) - BERSfr_M_c01_diamètre: 160 mm; BERSfr_M_c02_diamètre: 125 mm; BERSfr_M_c03_diamètre: 125 mm
Type - Identity Data(Type) - Assembly Code: 57,1; BERSfr_C_code_article: 0000-4334; BERSfr_C_code_ETIM: "Fitting met 3 aansluitingen"; BERSfr_C_code_ETIM_url: https://prod.etim-international.com/Class/Details?classId=EC003025&classVersion=2; BERSfr_C_content_créateur: ThorbiQ nv; BERSfr_C_content_date_issue: 06/02/2018; BERSfr_C_content_date_modifié: 23/03/2018; BERSfr_C_content_fournisseur: Duco; BERSfr_C_content_version: V1; BERSfr_C_description: duco_culottes type d'y - 2 x 125 mm à 1 x 160 mm; BERSfr_C_IFC_version: 2016; BERSfr_C_modèle: culottes type d'y; BERSfr_C_revit_version: 2016; BERSfr_C_type: 2 x 125 mm à 1 x 160 mm; BERSfr_C_type_commentaires: culottes type d'y; Description: duco_culottes type d'y - 2 x 125 mm à 1 x 160 mm; Manufacturer: Duco; Model: culottes type d'y; Type Comments: culottes type d'y; Type Name: 2 x 125mm naar 1 x 160 mm_duco_culottes type d'y; URL: http://www.duco.eu/nl-nl-producten/nl-nl-luchtafvoer/nl-nl-toebehoren/nl-nl-broekstuk; WT_I BaseKeynote: 57.10
Type - Materials and Finishes(Type) - BERSfr_C_matériel: BERSfr_x_rgb 20 20 20 T00 noir_gen
Type - Other(Type) - Category: Duct Fittings; Family Name: BERSfr_57_DUF_UN_culottes type d'y_duco
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: 2 x 125mm naar 1 x 160 mm_duco_culottes type d'y
Constraints - Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.000282712 m2; Size: 160 mmø-125 mmø-125 mmø; Volume: 2.35515e-07 m3
Identity Data - Mark: 1
Insulation - Insulation Thickness: 0 mm; Overall Size: 160 mmø-125 mmø-125 mmø
Lining - Free Size: 160 mmø-125 mmø-125 mmø; Lining Thickness: 0 mm
Mechanical - System Classification: Undefined
Other - Category: Duct Fittings; Family: BERSfr_57_DUF_UN_culottes type d'y_duco: 2 x 125mm naar 1 x 160 mm_duco_culottes type d'y; Family and Type: BERSfr_57_DUF_UN_culottes type d'y_duco: 2 x 125mm naar 1 x 160 mm_duco_culottes type d'y; Type: BERSfr_57_DUF_UN_culottes type d'y_duco: 2 x 125mm naar 1 x 160 mm_duco_culottes type d'y; Type Id: BERSfr_57_DUF_UN_culottes type d'y_duco: 2 x 125mm naar 1 x 160 mm_duco_culottes type d'y
Phasing - Phase Created: New Construction
Text - BERSfr_C_content_instructions: http://www.witas.be/nl/duco
