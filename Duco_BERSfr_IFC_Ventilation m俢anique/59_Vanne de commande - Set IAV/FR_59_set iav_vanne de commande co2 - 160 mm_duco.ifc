Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T17:06:16
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 17:06:16 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{6F5C0D81-EB73-4838-B0FF-5F3FB958872B}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 17:06:16 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 17:06:16 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 17:06:16 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: vanne de commande co2 - 160 mm_duco_set iav_bxhxd 220x183x138, BERSfr_59_DUA_UN_vanne de commande - set iav_duco:vanne de commande co2 - 160 mm_duco_set iav_bxhxd 220x183x138:201295
In: Level 1
Type - PredefinedType: CONTROLDAMPER; Classification: 57.10.90.80 (Uniformat); Material: BERSfr_x_rgb 255 255 255 T00 blanc_gen, BERSfr_x_rgb 000 149 150 T00 vert_gen
Type - Constraints(Type) - ZZZ_Behuizing_FamilyType_Duct Accessories: standard
Type - Dimensions(Type) - BERSfr_C_hauteur: 183 mm; BERSfr_C_largeur: 220 mm; BERSfr_C_profondeur: 138 mm
Type - Electrical(Type) - BERSfr_E_c01_courant: 1 A; BERSfr_E_c01_facteur_de_puissance: 1; BERSfr_E_c01_indice_de_charge: HVAC; BERSfr_E_c01_nombre_des_pôles: 1; BERSfr_E_c01_puissance_active: 7 W; BERSfr_E_c01_puissance_apparente: 24 W; BERSfr_E_c01_sous_indice_de_charge_moteur: yes; BERSfr_E_c01_tension: 24 V; WT_I Stand-By puissance: 0.4 W
Type - Identity Data(Type) - Assembly Code: 57.10.90.80; BERSfr_C_code_article: -; BERSfr_C_code_ETIM: vanne de commande chaîne circulaire; BERSfr_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC011268&classVersion=3; BERSfr_C_content_créateur: ThorbiQ nv; BERSfr_C_content_date_issue: 06/02/2018; BERSfr_C_content_date_modifié: 23/03/2018; BERSfr_C_content_fournisseur: Duco; BERSfr_C_content_version: V1; BERSfr_C_description: duco_set intelli air valve - vanne de commande co2; BERSfr_C_IFC_version: 2x3; BERSfr_C_modèle: Set Intelli Air Valve; BERSfr_C_revit_version: 2016; BERSfr_C_type: vanne de commande CO2; BERSfr_C_type_commentaires: vanne de commande; Description: duco_set intelli air valve - vanne de commande co2; Manufacturer: Duco; Model: Set Intelli Air Valve; OmniClass Number: 23.75.70.14.34; OmniClass Title: Air Duct Accessories; Type Comments: vanne de commande; Type Name: vanne de commande co2 - 160 mm_duco_set iav_bxhxd 220x183x138; URL: http://www.duco.eu; WT_I BaseKeynote: 31.20
Type - Materials and Finishes(Type) - BERSfr_C_matériel: BERSfr_x_rgb 000 149 150 T00 vert_gen; BERSfr_C_matériel_01: BERSfr_x_rgb 000 149 150 T00 vert_gen; BERSfr_C_matériel_02: BERSfr_x_rgb 255 255 255 T00 blanc_gen
Type - Mechanical(Type) - BERSfr_M_c01_diamètre: 160 mm
Type - Model Properties(Type) - BERSfr_S_poids_brut: 0.628; WT_I Applicable dans les systèmes suivants: Duco CO2 System collectif, Duco Comfort Plus System collectif, Duco Tronic System collectif, Duco Tronic Plus System collectif; WT_I Communication: Câblé avec le maître parent (le cas échéant), RF avec les composants esclaves sous-jacents
Type - Other(Type) - Category: Duct Accessories; BERSfr_E_c03_description: c03_connection; BERSfr_M_c01_description: c01_connection; BERSfr_M_c02_description: c02_connection; Family Name: BERSfr_59_DUA_UN_vanne de commande - set iav_duco
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: vanne de commande co2 - 160 mm_duco_set iav_bxhxd 220x183x138
Constraints - Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.125949 m2; Size: 160 mmø-160 mmø; Volume: 0.0058858 m3
Identity Data - Mark: 5
Insulation - Insulation Thickness: 0 mm; Overall Size: 160 mmø-160 mmø
Lining - Free Size: 160 mmø-160 mmø; Lining Thickness: 0 mm
Mechanical - System Classification: Undefined,Power
Other - Category: Duct Accessories; Family: BERSfr_59_DUA_UN_vanne de commande - set iav_duco: vanne de commande co2 - 160 mm_duco_set iav_bxhxd 220x183x138; Family and Type: BERSfr_59_DUA_UN_vanne de commande - set iav_duco: vanne de commande co2 - 160 mm_duco_set iav_bxhxd 220x183x138; Type: BERSfr_59_DUA_UN_vanne de commande - set iav_duco: vanne de commande co2 - 160 mm_duco_set iav_bxhxd 220x183x138; Type Id: BERSfr_59_DUA_UN_vanne de commande - set iav_duco: vanne de commande co2 - 160 mm_duco_set iav_bxhxd 220x183x138
Phasing - Phase Created: New Construction
Text - BERSfr_C_content_instructions: http://www.witas.be/nl/duco
