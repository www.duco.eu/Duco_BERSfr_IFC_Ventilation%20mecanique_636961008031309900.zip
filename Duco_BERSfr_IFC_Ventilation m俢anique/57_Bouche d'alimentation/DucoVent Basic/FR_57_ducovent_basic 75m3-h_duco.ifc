Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T17:02:24
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 17:02:24 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{8A78C0A3-9EE1-4FCC-A435-F91D20C4146A}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 17:02:17 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 17:02:17 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 17:02:17 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: basic 75m3/h_duco_ducovent, BERSfr_57_AIR_FB_bouche d'extraction - ducovent basic_duco:basic 75m3/h_duco_ducovent:201055
In: Level 1
Type - PredefinedType: GRILLE; Classification: 57.10.90.1 (Uniformat)
Type - Constraints(Type) - Default Elevation: 2000 mm; ZZZ_connection profondeur_Length: -20 mm; ZZZ_hauteur_Length: 1 mm; ZZZ_largeur_Length: 1 mm; ZZZ_rayon_Length: 100 mm
Type - Dimensions(Type) - BERSfr_C_diamètre: 200 mm; BERSfr_C_hauteur: 0 mm; BERSfr_C_largeur: 0 mm; BERSfr_C_profondeur: 50 mm; BERSfr_M_c01_diamètre: 125 mm; WT_V Raccordement profondeur: 20 mm
Type - Identity Data(Type) - Assembly Code: 57.10.90.1; BERSfr_C_code_article: 0000-4178; BERSfr_C_code_ETIM: Passage d'air; BERSfr_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC010230&classVersion=5; BERSfr_C_code_gtin: 5 4 2503715 017 0; BERSfr_C_content_créateur: ThorbiQ nv; BERSfr_C_content_date_modifié: 23/03/2018; BERSfr_C_content_date_problème: 26/02/2016; BERSfr_C_content_fournisseur: Duco; BERSfr_C_content_version: V4; BERSfr_C_description: duco_bouche d'extraction_ducovent_basic 75m3/h; BERSfr_C_modèle: Ducovent; BERSfr_C_revit_version: 2014; BERSfr_C_type: Basic; Cost: 0; Description: duco_bouche d'extraction_ducovent_basic 75m3/h; Manufacturer: Duco; Model: Ducovent; Type Name: basic 75m3/h_duco_ducovent; URL: http://www.duco-professionals.eu/Wes/Website/nl-NL/Search?recordsPerPage=5&sortBy=relevance&term=ducovent; WT_I BaseKeynote: 57.10.90.1
Type - Mechanical - Flow(Type) - Max Flow: 0.735722 m3/s
Type - Model Properties(Type) - WT_I Couleur: Ral 9010_blanc; WT_I Hauteur de montage: min. 18 cm au dessus du sol; WT_I Montage sur minimum: minimium 60 cm du mur et plafond; WT_I Niveau sonore: -
Type - Other(Type) - Category: Air Terminals; BERSfr_M_c01_description: c01_extraction; BERSfr_M_c01_perte_de_charge_statique: 0 Pa; BERSfr_M_c01_rayon: 62.5 mm; Family Name: BERSfr_57_AIR_FB_bouche d'extraction - ducovent basic_duco
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: basic 75m3/h_duco_ducovent
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Area: 0.0549737 m2; Size: 125 mmø; Volume: 0.00235608 m3
Identity Data - Mark: 1
Mechanical - System Classification: Return Air
Mechanical - Flow - BERSfr_M_débit: 0 m3/s; Flow: 0 m3/s; WT_I Débit maximal: OK
Other - BERSfr_M_c01_débit: 0 m3/s; Category: Air Terminals; Family: BERSfr_57_AIR_FB_bouche d'extraction - ducovent basic_duco: basic 75m3/h_duco_ducovent; Family and Type: BERSfr_57_AIR_FB_bouche d'extraction - ducovent basic_duco: basic 75m3/h_duco_ducovent; Schedule Level: Level: Level 1; Type: BERSfr_57_AIR_FB_bouche d'extraction - ducovent basic_duco: basic 75m3/h_duco_ducovent; Type Id: BERSfr_57_AIR_FB_bouche d'extraction - ducovent basic_duco: basic 75m3/h_duco_ducovent
Phasing - Phase Created: New Construction
Text - BERSfr_C_content_instructions: http://www.witas.be/nl/duco
