Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T17:02:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 17:02:07 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{B6C56BEC-CC23-406F-85DC-E69959EF7F95}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 17:02:01 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 17:02:02 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 17:02:02 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: bouche d'alimentation - rond_duco_ducovent design, BERSfr_57_AIR_FB_bouche d'alimentation - ducovent design_duco:bouche d'alimentation - rond_duco_ducovent design:201613
In: Level 1
Type - PredefinedType: GRILLE; Classification: 57.10.90.1 (Uniformat); Material: BERSfr_n6_PVC_blanc
Type - Constraints(Type) - Default Elevation: 2000 mm
Type - Dimensions(Type) - BERSfr_C_diamètre: 215 mm; BERSfr_C_hauteur: 73.5 mm; BERSfr_C_largeur: 0 mm; BERSfr_C_profondeur: 22 mm; BERSfr_M_c01_diamètre: 125 mm; WT_V Raccordement profondeur: 52 mm
Type - Identity Data(Type) - Assembly Code: 57.10.90.1; BERSfr_C_code_article: 4210; BERSfr_C_code_ETIM: Passage d'air; BERSfr_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC010230&classVersion=5; BERSfr_C_code_gtin: -; BERSfr_C_content_créateur: ThorbiQ nv; BERSfr_C_content_date_modifié: 23/03/2018; BERSfr_C_content_date_problème: 22/04/2016; BERSfr_C_content_fournisseur: Duco; BERSfr_C_content_version: V1; BERSfr_C_description: duco_ducovent design_bouche d'alimentation - rond; BERSfr_C_modèle: ducovent design; BERSfr_C_revit_version: 2014; BERSfr_C_type: rond; BERSfr_C_type_commentaires: bouche d'alimentation; Cost: 0; Description: duco_ducovent design_bouche d'alimentation - rond; Manufacturer: Duco; Model: ducovent design; Type Comments: bouche d'alimentation; Type Name: bouche d'alimentation - rond_duco_ducovent design; URL: http://www.duco.eu/producten/luchtafvoer/afvoerventielen/nl-be-ducoventdesign; WT_I BaseKeynote: 57.10.90.1
Type - Materials and Finishes(Type) - BERSfr_C_matériel: BERSfr_n6_PVC_blanc
Type - Mechanical - Flow(Type) - Max Flow: 0.735722 m3/s
Type - Model Properties(Type) - WT_I Couleur: Ral 9010_blanc; WT_I Hauteur d'installation: min. 18 cm au dessus du sol; WT_I Montage sur minimum: minimium 60 cm du mur et plafond; WT_I Niveau sonore: <15 dB(A) à 50 m3/h
Type - Other(Type) - Category: Air Terminals; BERSfr_M_c01_description: c01_alimentation; BERSfr_M_c01_perte_de_charge_statique: 0 Pa; BERSfr_M_c01_rayon: 62.5 mm; Family Name: BERSfr_57_AIR_FB_bouche d'alimentation - ducovent design_duco
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: bouche d'alimentation - rond_duco_ducovent design
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Area: 0.0611227 m2; Size: 125 mmø; Volume: 0.00266829 m3
Identity Data - Mark: 3
Mechanical - System Classification: Supply Air
Mechanical - Flow - BERSfr_M_débit: 0 m3/s; Flow: 0 m3/s; WT_I Débit maximal: OK
Other - BERSfr_M_c01_débit: 0 m3/s; Category: Air Terminals; Family: BERSfr_57_AIR_FB_bouche d'alimentation - ducovent design_duco: bouche d'alimentation - rond_duco_ducovent design; Family and Type: BERSfr_57_AIR_FB_bouche d'alimentation - ducovent design_duco: bouche d'alimentation - rond_duco_ducovent design; Schedule Level: Level: Level 1; Type: BERSfr_57_AIR_FB_bouche d'alimentation - ducovent design_duco: bouche d'alimentation - rond_duco_ducovent design; Type Id: BERSfr_57_AIR_FB_bouche d'alimentation - ducovent design_duco: bouche d'alimentation - rond_duco_ducovent design
Phasing - Phase Created: New Construction
Text - BERSfr_C_content_instructions: http://www.witas.be/nl/duco
