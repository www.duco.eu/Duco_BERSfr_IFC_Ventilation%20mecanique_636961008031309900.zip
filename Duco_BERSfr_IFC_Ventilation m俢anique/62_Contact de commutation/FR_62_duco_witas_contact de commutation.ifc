Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T17:06:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 17:06:49 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{D4BBD866-D789-4F41-BAF7-3B8646F07192}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 17:06:48 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 17:06:48 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 17:06:48 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowFitting: contact de commutation_duco_bxhxd 41x37x20 mm, BERSfr_62_EF_FB_contact de commutation_duco_witas:contact de commutation_duco_bxhxd 41x37x20 mm:199813
In: Level 1
Type - Classification: 62,6 (Uniformat); Material: BERSfr_x_rgb 255 255 255 T00 blanc_gen
Type - Constraints(Type) - Default Elevation: 1100 mm
Type - Construction(Type) - WT_V Epaisseur cadre de recouvrement: 13 mm
Type - Dimensions(Type) - BERSfr_C_hauteur: 37 mm; BERSfr_C_largeur: 41 mm; BERSfr_C_profondeur: 20 mm
Type - Electrical(Type) - BERSfr_E_c01_courant: 1 A; BERSfr_E_c01_facteur_de_puissance: 1; BERSfr_E_c01_indice_de_charge: HVAC; BERSfr_E_c01_nombre_des_pôles: 1; BERSfr_E_c01_puissance: 0.5 W; BERSfr_E_c01_puissance_apparente: 230 W; BERSfr_E_c01_sous_indice_de_charge_moteur: no; BERSfr_E_c01_tension: 230 V; BERSfr_E_puissance: 0.5 W
Type - Identity Data(Type) - Assembly Code: 62,6; BERSfr_C_code_article: 0000-4174; BERSfr_C_code_ETIM: "Overige elektronische elementen schakelmateriaal"; BERSfr_C_code_ETIM_url: https://prod.etim-international.com/Class/Details?classId=EC000636&classVersion=7; BERSfr_C_content_créateur: ThorbiQ nv; BERSfr_C_content_date_issue: 06/02/2018; BERSfr_C_content_date_modifié: 23/03/2018; BERSfr_C_content_fournisseur: Duco; BERSfr_C_content_version: V1; BERSfr_C_description: duco_contact de commutation; BERSfr_C_IFC_version: 2x3; BERSfr_C_modèle: contact de commutation; BERSfr_C_revit_version: 2016; BERSfr_C_type: contact de commutation; BERSfr_C_type_commentaires: Contact de commutation; Description: duco_contact de commutation; Manufacturer: Duco; Model: contact de commutation; Type Comments: Contact de commutation; Type Name: contact de commutation_duco_bxhxd 41x37x20 mm; URL: http://www.duco.eu/nl-nl-producten/nl-nl-ventilatiesystemen/nl-nl-sturingscomponenten/nl-nl-externe-sturingscomponenten/nl-nl-schakelcontact; WT_I BaseKeynote: 62.60
Type - Materials and Finishes(Type) - BERSfr_C_matériel: BERSfr_x_rgb 255 255 255 T00 blanc_gen; BERSfr_C_matériel_01: BERSfr_x_rgb 255 255 255 T00 blanc_gen; BERSfr_C_matériel_02: BERSfr_x_rgb 000 149 150 T00 vert_gen
Type - Model Properties(Type) - BERSfr_S_poids_brut: 0.021; WT_I Couleur: Blanc; WT_I Puissance de réserve: 0,4 W
Type - Other(Type) - Category: Electrical Fixtures; BERSfr_E_c02_description: c02_commande; Family Name: BERSfr_62_EF_FB_contact de commutation_duco_witas
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: contact de commutation_duco_bxhxd 41x37x20 mm
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Area: 0.009188 m2; Volume: 0.00006068 m3
Electrical - Circuiting - Electrical Data: c01_connection 230 V/1-230 VA
Graphics - WT_V Annotatie_positie x: 0; WT_V Annotatie_positie y: 0; WT_V Annotatie_verschuiving x richting: 0 mm; WT_V Annotatie_verschuiving y richting: 0 mm
Identity Data - Mark: 1
Other - BERSfr_E_c01_description: c01_connection; Category: Electrical Fixtures; Family: BERSfr_62_EF_FB_contact de commutation_duco_witas: contact de commutation_duco_bxhxd 41x37x20 mm; Family and Type: BERSfr_62_EF_FB_contact de commutation_duco_witas: contact de commutation_duco_bxhxd 41x37x20 mm; Schedule Level: Level: Level 1; Type: BERSfr_62_EF_FB_contact de commutation_duco_witas: contact de commutation_duco_bxhxd 41x37x20 mm; Type Id: BERSfr_62_EF_FB_contact de commutation_duco_witas: contact de commutation_duco_bxhxd 41x37x20 mm
Phasing - Phase Created: New Construction
Text - BERSfr_C_content_instructions: http://www.witas.be/nl/duco
